Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 952ef6bf-293a-49d3-979e-d44560835757, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T22:02:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11144440_NER_KM7697FL:26769770_NER_11144440_KM7697FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, <Unnamed>, z_Miele_Design_Glass Black, Default
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 936 mm; Height: 51 mm; Depth: 520 mm
Pset_BuildingElementProxyCommon - Reference: 26769770_NER_11144440_KM7697FL; sets with these values: 2
